# Repository XuHg-zjcn/battery_charger_sc8802

File README.md:

# SC8802电池充电器
双向可充电和放电，最高支持30V电池电压和输入输出电压，用于给笔记本电池，电动工具电池等内部没有电压转换模块的电池组充电，可以当USB移动电源，也可以作为储能单元
## 目标特征
- 与[SmartBattery协议](https://en.wikipedia.org/wiki/Smart_Battery_System)电池通信
- 使用[USB PD协议](https://en.wikipedia.org/wiki/USB_hardware#USB_Power_Delivery)连接外部设备进行充电和放电
- 可调电源
- 支持使用太阳能等功率受限电源MPPT充电
- 与电源管理中心通信，并接受调度

## 版权和许可证
Copyright (C) 2026  徐瑞骏  
本设计使用的为许可证“CERN Open Hardware Licence Version 2 - Strongly Reciprocal”

## KiCad design battery_charger_sc8802.kicad_pcb

Parts:
C1, C2: 47p; C_0402_1005Metric
C3, C4, C6, C7, C8: C_Small; C_0402_1005Metric
C5, C17, C18: C; C_0603_1608Metric
C9: 0.1uF; C_0603_1608Metric
C10, C11: 100nF 100V; C_0603_1608Metric
C12: 1uF 100V; C_0805_2012Metric
C13: 100nF; C_0402_1005Metric
C14, C15, C16: 10uF; C_0805_2012Metric
D1, D2: D_Small; D_SOD-523
D3: 2.0V; D_SOD-323
D4, D5, D6: CESDB5V0D3; D_SOD-323
D7: DSK210; D_SOD-123F
D8, D9, D10, D11: D; D_SOD-323
D12: LED_ABGR; LED_RGB_1210
F1, F2: 20mA; Fuse_0603_1608Metric
FB1, FB2: 1000R; L_0603_1608Metric
GD1, GD2, GD3: 75V; C_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: USB_A; USB_A_Molex_67643_Horizontal
J3: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J4: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
L1: L; L_APV_ANR8065
L2: 1000R; L_CommonModeChoke_Coilcraft_1812CAN
L3: 47uH; L_1210_3225Metric
Q1, Q2, Q3, Q4: Q_NMOS_GSD; TO-252-2
Q5, Q12, Q13, Q14: Q_NPN_BCE; SOT-23
Q6, Q9, Q11: Q_NMOS_GSD; SOT-23
Q7, Q8, Q10: PNP; SOT-23
R1, R2, R3, R4, R17, R18, R19, R20, R21, R22, R35, R36, R37: R_Small; R_0402_1005Metric
R5, R6: R; R_1206_3216Metric
R7, R8, R9, R10: 1k; R_0402_1005Metric
R11, R12, R13, R14, R15, R16, R30, R32, R33, R34: R; R_0603_1608Metric
R23, R24: 22R; R_0603_1608Metric
R25, R26, R27: 1M; R_0603_1608Metric
R28: 20k; R_0402_1005Metric
R29: 100k; R_0402_1005Metric
R31, R38, R39, R40: R; R_0402_1005Metric
U1: SC8802QDER; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm
U4: YX59012; SOT-23-6
U5: SGM2033-3.3; SOT-23-5

Connections:
+3.3V: C16.1, U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U5.5 (OUT)
+5V: C9.2, C14.1, C15.1, L3.2, R29.2, U3.8 (VCC), U5.1 (IN), U5.3 (EN)
+BATT: D10.2 (A), J3.1, J3.2, J4.1, R6.2, R10.1, R15.2, U1.19 (VBAT)
/485+: C10.2, GD1.1, GD2.1
/485-: C11.2, GD2.2, GD3.1
/DC_EN: U4.4 (~SHDN)
/DIR: U1.2 (DIR)
/IPWM: U1.5 (IPWM)
/MAX485_DI: U3.4 (DI)
/MAX485_RO: D3.2 (A)
/MAX485_TR: U3.2 (~RE), U3.3 (DE)
/OUTEN_Other: R40.1
/OUTEN_USBA: R39.1
/OUTEN_USBC: R38.1
/PG: U1.4 (PG)
/PWM: U1.3 (PWM)
/PWM_boost: R31.1
/SMB_DET: J3.5
/SMB_SCL: J3.3
/SMB_SDA: J3.4
/USBA_D+: J2.3 (D+)
/USBA_D-: J2.2 (D-)
/USBA_VBUS: J2.1 (VBUS), Q9.2 (S), R36.2
/USBC_CC1: J1.A5 (CC1)
/USBC_CC2: J1.B5 (CC2)
/USBC_D+: J1.A6 (D+), J1.B6 (D+)
/USBC_D-: J1.A7 (D-), J1.B7 (D-)
/USBC_VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q6.2 (S), R35.2
/~CE: U1.1 (~CE)
GND: C5.1, C6.2, C7.2, C8.2, C9.1, C12.1, C14.2, C15.2, C16.2, D4.2 (A), D6.2 (A), D7.2 (A), GD1.2, GD3.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4 (GND), J2.5 (Shield), J3.6, J3.7, J4.2, Q2.2 (S), Q4.2 (S), Q5.3 (E), Q12.3 (E), Q13.3 (E), Q14.3 (E), R13.1, R14.1, R16.1, R17.2, R20.2, R21.2, R22.2, R25.2, R27.2, R28.1, U1.14 (AGND), U1.25 (PGND), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.5 (GND), U4.2 (GND), U5.2 (GND)
unnamed: C7.1, R18.2
unnamed: C10.1, FB1.2
unnamed: C11.1, FB2.2
unnamed: C3.1, D1.1 (K), U1.29 (BT1)
unnamed: C4.2, D2.1 (K), U1.20 (BT2)
unnamed: D3.1 (K), U3.1 (RO)
unnamed: D4.1 (K), D5.1 (K), F1.1, L2.2, R25.1, R26.1
unnamed: D5.2 (A), D6.1 (K), F2.1, L2.3, R26.2, R27.1
unnamed: C13.2, D7.1 (K), L3.1, U4.6 (SW)
unnamed: C17.1, D8.1 (K), D9.2 (A)
unnamed: C18.1, D9.1 (K), Q7.3 (E), Q8.3 (E), Q10.3 (E)
unnamed: C12.2, D10.1 (K), D11.1 (K), U4.5 (VIN)
unnamed: F1.2, FB1.1
unnamed: F2.2, FB2.1
unnamed: L2.1, R23.2
unnamed: L2.4, R24.2
unnamed: Q1.3 (D), R5.2, R8.1
unnamed: Q1.1 (G), R1.2
unnamed: C3.2, L1.1, Q1.2 (S), Q2.3 (D), U1.27 (SW1)
unnamed: Q2.1 (G), R2.2
unnamed: Q3.3 (D), R6.1, R9.1
unnamed: Q3.1 (G), R3.1
unnamed: C4.1, L1.2, Q3.2 (S), Q4.3 (D), U1.22 (SW2)
unnamed: Q4.1 (G), R4.1
unnamed: Q5.1 (B), R31.2
unnamed: C17.2, Q5.2 (C), R30.2
unnamed: Q6.1 (G), Q7.1 (C), R35.1
unnamed: Q7.2 (B), R32.1
unnamed: Q8.2 (B), R33.1
unnamed: Q8.1 (C), Q9.1 (G), R36.1
unnamed: Q10.2 (B), R34.1
unnamed: Q10.1 (C), Q11.1 (G), R37.1
unnamed: Q11.2 (S), R37.2
unnamed: Q12.1 (B), R38.2
unnamed: Q12.2 (C), R32.2
unnamed: Q13.1 (B), R39.2
unnamed: Q13.2 (C), R33.2
unnamed: Q14.1 (B), R40.2
unnamed: Q14.2 (C), R34.2
unnamed: R18.1, U1.15 (COMP)
unnamed: R21.1, U1.9 (CSEL)
unnamed: R20.1, U1.8 (DT)
unnamed: R12.1, R14.2, U1.13 (FB1)
unnamed: R15.1, R16.2, U1.16 (FB2)
unnamed: R22.1, U1.10 (FREQ)
unnamed: R1.1, U1.28 (HD1)
unnamed: R3.2, U1.21 (HD2)
unnamed: C8.1, R19.2, U1.11 (ILIM1)
unnamed: C6.1, R17.1, U1.12 (ILIM2)
unnamed: R19.1, U1.6 (ITUNE)
unnamed: R2.1, U1.26 (LD1)
unnamed: R4.2, U1.23 (LD2)
unnamed: C1.2, R8.2, U1.31 (SNS1N)
unnamed: C1.1, R7.2, U1.32 (SNS1P)
unnamed: C2.2, R10.2, U1.17 (SNS2N)
unnamed: C2.1, R9.2, U1.18 (SNS2P)
unnamed: R11.1, R13.2, U1.7 (VINREG)
unnamed: R23.1, U3.6 (A)
unnamed: R24.1, U3.7 (B)
unnamed: C13.1, U4.1 (CB)
unnamed: R28.2, R29.1, U4.3 (FB)
VBUS: C18.2, D11.2 (A), Q6.3 (D), Q9.3 (D), Q11.3 (D), R5.1, R7.1, R11.2, R12.2, R30.1, U1.30 (VBUS)
VCC: C5.2, D1.2 (A), D2.2 (A), D8.2 (A), U1.24 (VCC)

Notes on the sheet:
接口电路待添加TVS等保护
待添加0.96寸OLED

Board: 2 copper layers, 103 parts (0 on the bottom side), 74 nets, no tracks yet.
